# IAR project wolfSSL-Lib_RA6_FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA6E10F Renesas R7FA6E10F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: WOLFSSL_USER_SETTINGS
  ICCARM.CCDiagSuppress: Pa050,Pa089,Pe177,Pa084
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..; ..\..\..\..\..\..\MTU\Common; ..\..\..\..\..\..\Common; ..\..\..\..\..\..\MTU\Common\BuildConfig\RA6_FreeRTOS; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\ra\fsp\src\bsp\cmsis\Device\RENESAS\Include; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\ra\arm\CMSIS_5\CMSIS\Core\Include; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\ra\fsp\inc; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\ra\fsp\inc\api; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\ra\fsp\inc\instances; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\ra\fsp\src\rm_freertos_port; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\ra_gen; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\src; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\ra_cfg\aws; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\ra_cfg\driver; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\ra\board; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\ra_cfg\fsp_cfg; ..\..\..\..\..\..\MTU\OS_BSP\FreeRTOS_RA6\ra_cfg\fsp_cfg\bsp; ..\..\..\..\..\..\Common\FreeRTOS\10.4.3\aws\amazon-freertos\freertos_kernel\include; ..\..\..\..\..\..\Common\FreeRTOS\10.4.3\aws\amazon-freertos\libraries\freertos_plus\standard\freertos_plus_tcp\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CyaSSL-Full.srec
  ILINK.IlinkOutputFile: CyaSSL-Full.out
  ILINK.IlinkIcfFile: CyaSSL-Full.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BuildConfig
    ../../../../wolfssl/wolfcrypt/: settings.h settings_FreeRTOS.h
    ../../../../../../MTU/Common/BuildConfig/RA6_FreeRTOS/: user_settings.h
  group wolfCrypt
    ../../../../wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c cpuid.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c pkcs12.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha3.c sha512.c signature.c sp_arm32.c sp_arm64.c sp_c32.c sp_c64.c sp_int.c srp.c tfm.c wc_encrypt.c wc_port.c wolfevent.c wolfmath.c
  group wolfSSL
    ../../../../src/: crl.c internal.c keys.c ocsp.c quicksession.c sniffer.c ssl.c tls.c tls13.c wolfio.c
