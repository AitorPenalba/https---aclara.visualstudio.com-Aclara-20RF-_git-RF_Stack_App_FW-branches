# IAR project wolfSSL-Lib_K24_MQX.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN1M0xxx12 NXP MK24FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RTOS_SELECTION= MQX; WOLFSSL_USER_SETTINGS
  ICCARM.CCDiagSuppress: Pa050,Pa089,Pe177
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..; ..\..\..\..\..\..\MTU\OS_BSP\MQX_Kinetis\config\common; ..\..\..\..\..\..\MTU\OS_BSP\MQX_Kinetis\config\ep_k24f120m; ..\..\..\..\..\..\MTU\OS_BSP\MQX_Kinetis\mqx\source\include; ..\..\..\..\..\..\MTU\OS_BSP\MQX_Kinetis\mqx\source\psp\cortex_m; ..\..\..\..\..\..\MTU\OS_BSP\MQX_Kinetis\mqx\source\psp\cortex_m\compiler\iar; ..\..\..\..\..\..\MTU\OS_BSP\MQX_Kinetis\mqx\source\psp\cortex_m\cpu; ..\..\..\..\..\..\MTU\Common; ..\..\..\..\..\..\MTU\Common\BuildConfig\K24_MQX
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CyaSSL-Full.srec
  ILINK.IlinkOutputFile: CyaSSL-Full.out
  ILINK.IlinkIcfFile: CyaSSL-Full.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BuildConfig
    ../../../../wolfssl/wolfcrypt/: settings.h settings_MQX.h
    ../../../../../../MTU/Common/BuildConfig/K24_MQX/: user_settings.h
  group wolfCrypt
    ../../../../wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c cpuid.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c pkcs12.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha3.c sha512.c signature.c sp_arm32.c sp_arm64.c sp_c32.c sp_c64.c sp_int.c srp.c tfm.c wc_encrypt.c wc_port.c wolfevent.c wolfmath.c
  group wolfSSL
    ../../../../src/: crl.c internal.c keys.c ocsp.c quicksession.c sniffer.c ssl.c tls.c tls13.c wolfio.c
