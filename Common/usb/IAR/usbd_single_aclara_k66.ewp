# IAR project usbd_single_aclara_k66.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 Freescale MK66FN2M0xxx18
  ICCARM.CCDefines: _DEBUG=1; xDEV_DEBUG=1; xKHCI_DEBUG=1; CPU_MK24FN1M0VDC12=1
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe186, Pe1665
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$/inc/Freescale; ..\src\Single Device\include; ..\src\Single Device; ..\..\..\DCU\Frodo_9985T\Project; ..\..\..\DCU\OS\mqx\source\include; ..\..\..\DCU\Common\include; ..\..\..\DCU\OS\config\dcu_k66f180m; ..\..\..\DCU\OS\config\common; ..\..\..\DCU\OS\mqx\source\psp\cortex_m; ..\..\..\DCU\OS\mqx\source\psp\cortex_m\compiler\iar; ..\..\..\DCU\OS\lib\dcu_k66f180m.iar\debug\psp; ..\..\..\DCU\OS\lib\dcu_k66f180m.iar\debug\bsp; ..\..\..\DCU\OS\lib\dcu_k66f180m.iar\debug\bsp\Generated_Code
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  ILINK.IlinkOutputFile: psp_arm.out
  group USB Class Drivers/audio
    ../src/Single Device/classes/audio/: usb_audio.c
    ../src/Single Device/include/: usb_audio.h
  group USB Class Drivers/cdc
    ../src/Single Device/classes/cdc/: usb_cdc.c usb_cdc_pstn.c usb_cdc_pstn.h
    ../src/Single Device/include/: usb_cdc.h
  group USB Class Drivers/framework
    ../src/Single Device/classes/common/: usb_framework.c
    ../src/Single Device/include/: usb_framework.h
  group USB Class Drivers/hid
    ../src/Single Device/classes/hid/: usb_hid.c
    ../src/Single Device/include/: usb_hid.h
  group USB Class Drivers/msd
    ../src/Single Device/classes/msd/: usb_msc.c usb_msc_scsi.c
    ../src/Single Device/include/: usb_msc.h usb_msc_scsi.h
  group USB Class Drivers/phdc
    ../src/Single Device/classes/phdc/: usb_phdc.c
    ../src/Single Device/include/: usb_phdc.h
  group USB Class Drivers/usb_class
    ../src/Single Device/classes/common/: usb_class.c
    ../src/Single Device/include/: usb_class.h
  group USB Device/include
    ../src/Single Device/include/: dev_cnfg.h dev_main.h devapi.h usb.h usb_debug.h usb_desc.h usb_error.h usb_misc.h usb_prv.h usb_stack_config.h usb_types.h
  group USB Device/os
    ../src/Single Device/include/: mqx_dev.h
  group USB Device/source
    ../src/Single Device/device/: dev_cncl.c dev_ep_deinit.c dev_main.c dev_recv.c dev_send.c dev_shut.c dev_utl.c
  group USB Low Level Driver/ehci
    ../src/Single Device/device/ehci/: callback_ehci.c ehci_dev_main.c ehci_dev_main.h ehci_usbprv.h
  group USB Low Level Driver/khci
    ../src/Single Device/device/khci/: callback_khci.c khci_dev_main.c khci_dev_main.h khci_usbprv.h
