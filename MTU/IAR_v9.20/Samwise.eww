<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bootLoader_K24.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\OS_BSP\MQX_Kinetis\mqx\build\iar\bsp_ep_k24f120m\bsp_ep_k24f120m.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\EdgeGateway_K24.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\OS_BSP\FreeRTOS_RA6\IAR\EP_FreeRTOS_RA6.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\I210+c_K24.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\I210+c_RA6.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\I210+c_RA6_Dev.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\I210+c_RA6_Dev_all.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\KV2c_K24.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LoadControl_K24.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\OS_BSP\MQX_Kinetis\mqx\build\iar\psp_ep_k24f120m\psp_ep_k24f120m.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\Common\wolfssl\IDE\IAR-EWARM\Projects\MTU\wolfSSL-Lib_K24_MQX.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\Common\wolfssl\IDE\IAR-EWARM\Projects\MTU\wolfSSL-Lib_RA6_FreeRTOS.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Bootloader K24</name>
            <member>
                <project>bootLoader_K24</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>EdgeGateway K24</name>
            <member>
                <project>bsp_ep_k24f120m</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>psp_ep_k24f120m</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_K24_MQX</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>bootLoader_K24</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>EdgeGateway_K24</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>I210+c K24</name>
            <member>
                <project>bsp_ep_k24f120m</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>psp_ep_k24f120m</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_K24_MQX</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>bootLoader_K24</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>I210+c_K24</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>KV2c K24</name>
            <member>
                <project>bsp_ep_k24f120m</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>psp_ep_k24f120m</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_K24_MQX</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>bootLoader_K24</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>KV2c_K24</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Libs K24</name>
            <member>
                <project>bsp_ep_k24f120m</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>psp_ep_k24f120m</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_K24_MQX</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>LoadControl K24</name>
            <member>
                <project>bsp_ep_k24f120m</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>psp_ep_k24f120m</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_K24_MQX</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>bootLoader_K24</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>LoadControl_K24</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>I210+c RA6 - Debug</name>
            <member>
                <project>EP_FreeRTOS_RA6</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_RA6_FreeRTOS</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>I210+c_RA6</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Libs RA6</name>
            <member>
                <project>EP_FreeRTOS_RA6</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_RA6_FreeRTOS</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
