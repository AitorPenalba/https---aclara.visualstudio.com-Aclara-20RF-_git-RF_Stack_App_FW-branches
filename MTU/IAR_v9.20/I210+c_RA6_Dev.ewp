# IAR project I210+c_RA6_Dev.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA6E10F Renesas R7FA6E10F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\TargetBuildConfigs\I210+c; ..\TargetBuildConfigs\I210+c\RA6; ..\Aclara_BSP; ..\Common; ..\Common\HMC; ..\Common\BuildConfig\RA6_FreeRTOS; ..\OS_BSP\FreeRTOS_RA6\ra\arm\CMSIS_5\CMSIS\Core\Include; ..\OS_BSP\FreeRTOS_RA6\ra\fsp\inc; ..\OS_BSP\FreeRTOS_RA6\ra\fsp\inc\api; ..\OS_BSP\FreeRTOS_RA6\ra\fsp\inc\instances; ..\OS_BSP\FreeRTOS_RA6\ra\fsp\src\rm_freertos_port; ..\OS_BSP\FreeRTOS_RA6\ra_gen; ..\OS_BSP\FreeRTOS_RA6\src; ..\..\Common; ..\..\Common\Driver; ..\..\Common\DFW; ..\..\Common\Flash; ..\..\Common\FreeRTOS\10.4.3\OS_AL; ..\..\Common\FreeRTOS\10.4.3\aws\amazon-freertos\freertos_kernel\include; ..\..\Common\FreeRTOS\10.4.3\aws\amazon-freertos\libraries\freertos_plus\standard\freertos_plus_tcp\include; ..\..\Common\NET; ..\..\Common\NET\DTLS; ..\..\Common\NET\IP; ..\..\Common\NET\MAC; ..\..\Common\NET\MTLS; ..\..\Common\NET\PHY; ..\..\Common\NET\PHY\SoftDemodulator; ..\..\Common\NET\PHY\SoftDemodulator\SoftDemodPreProcessor; ..\..\Common\NET\PHY\SoftDemodulator\PreambleDetector; ..\..\Common\NET\PHY\SoftDemodulator\SyncAndPayloadDemodulator; ..\..\Common\Radio; ..\..\Common\Radio\Si446x_Radio; ..\..\Common\Radio\Si446x_Radio\Si446x_Library; ..\..\Common\Radio\Si446x_Radio\Si446x_Library\Si446x; ..\..\Common\Security; ..\..\Common\wolfssl; ..\OS_BSP\FreeRTOS_RA6\ra_cfg\fsp_cfg; ..\OS_BSP\FreeRTOS_RA6\ra_cfg; ..\OS_BSP\FreeRTOS_RA6\ra_cfg\aws; ..\OS_BSP\FreeRTOS_RA6\ra_cfg\driver; ..\OS_BSP\FreeRTOS_RA6\ra_cfg\fsp_cfg\bsp; ..\OS_BSP\FreeRTOS_RA6\ra\board
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Y84580-1-V3.00.xx.hex
  prebuild: AppPreBuild.bat "$OBJ_DIR$\Source\EP_Common"
  postbuild: AppPostBuild.bat "$TOOLKIT_DIR$" "$TARGET_BPATH$"
  ILINK.IlinkOutputFile: Y84580-1-V3.00.xx.out
  ILINK.IlinkConfigDefines: TARGET=2
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Libraries/RA6_FreeRTOS/Debug
    ../OS_BSP/FreeRTOS_RA6/IAR/Debug/Exe/: FreeRTOS_RA6.a
  group Libraries/RA6_FreeRTOS_WolfSSL/Debug
    ../../Common/wolfssl/IDE/IAR-EWARM/Projects/MTU/RA6_FreeRTOS Debug/Exe/: wolfSSL-Lib_MTU_RA6_FreeRTOS.a
  group Source/Aclara_BSP
    ../Aclara_BSP/: ADC.c AES.c AGT.c AGT.h BSP_aclara.c BSP_aclara.h CGC.c CRC.c CRC.h LED.c RA6_OptionsMemory.c radio_hal.c radio_hal.h RTC.c UART.c WDOG.c
  group Source/Common
    ../../Common/: ALRM_Handler.c ALRM_Handler.h BUF_MemoryBuffers.c BUF_MemoryBuffers.h buffer.c buffer.h DBG_CommandLine.c DBG_CommandLine.h DBG_SerialDebug.c DBG_SerialDebug.h eng_res.c eng_res.h EVL_event_log.c EVL_event_log.h file_io.c file_io.h HEEP_util.c HEEP_UTIL.h invert_bits.c invert_bits.h MFG_Dtls.c MFG_Port.c MFG_Port.h MIMT_info.c MIMT_info.h mode_config.c mode_config.h object_list.c object_list.h partitions.c partitions.h SELF_test.c SELF_test.h sys_busy.c sys_busy.h Temperature.c Temperature.h time_DST.c time_DST.h time_sync.c time_sync.h time_sys.c time_sys.h vbat_reg.c vbat_reg.h virgin_device.c virgin_device.h
  group Source/Common/DFW
    ../../Common/DFW/: dfw_app.c dfw_app.h dfw_interface.c dfw_interface.h dfw_pckt.c dfw_pckt.h dfwtd_config.c dfwtd_config.h
  group Source/Common/Driver
    ../../Common/driver/: dvr_banked.c dvr_banked.h dvr_cache.c dvr_cache.h dvr_DAC0.c dvr_DAC0.h dvr_extflash.c dvr_extflash.h dvr_sectPreErase.c dvr_sectPreErase.h dvr_sharedMem.c dvr_sharedMem.h IF_intFlash.c IF_intFlash.h spi_mstr.c spi_mstr.h
  group Source/Common/Include
    ../../Common/: heep.h project.h
  group Source/Common/NET
    ../../Common/NET/: COMM.c COMM.h indication.c indication.h SM.c SM.h SM_Protocol.h smtd_config.c smtd_config.h
  group Source/Common/NET/DTLS
    ../../Common/NET/DTLS/: dtls.c dtls.h
  group Source/Common/NET/IP
    ../../Common/NET/IP/: STACK.c STACK.h STACK_Protocol.h
  group Source/Common/NET/MAC
    ../../Common/NET/MAC/: MAC.c MAC.h MAC_FrameEncoder.c MAC_FrameEncoder.h MAC_FrameManagement.c MAC_FrameManagement.h MAC_PacketManagement.c MAC_PacketManagement.h MAC_Protocol.h
  group Source/Common/NET/MTLS
    ../../Common/NET/MTLS/: mtls.c mtls.h
  group Source/Common/NET/PHY
    ../../Common/NET/PHY/: galois.c PHY.c PHY.h PHY_Protocol.h rs.c rs.h rsdec.c rsenc.c rsfec.h
  group Source/Common/NET/PHY/SoftDemodulator
    ../../Common/NET/PHY/SoftDemodulator/: SoftDemodulator.c SoftDemodulator.h
  group Source/Common/NET/PHY/SoftDemodulator/PreambleDetector
    ../../Common/NET/PHY/SoftDemodulator/PreambleDetector/: EstimateCarrierFrequencyOffset.c EstimateCarrierFrequencyOffset.h MaximizeEyeOpening.c MaximizeEyeOpening.h PerformCFOCompensation.c PerformCFOCompensation.h preamble_detect.c preamble_detect.h preambleDetector.c preambleDetector.h preambleDetector_data.c preambleDetector_data.h preambleDetector_initialize.c preambleDetector_initialize.h processDerotatedSamples.c processDerotatedSamples.h ScaleClipFreq2phase.c ScaleClipFreq2phase.h sign.c sign.h
  group Source/Common/NET/PHY/SoftDemodulator/SoftDemodPreProcessor
    ../../Common/NET/PHY/SoftDemodulator/SoftDemodPreProcessor/: fir_filt_circ_buff.c fir_filt_circ_buff.h gresample.c gresample.h phase2freq_wi_unwrap.c phase2freq_wi_unwrap.h rtwtypes.h
  group Source/Common/NET/PHY/SoftDemodulator/SyncAndPayloadDemodulator
    ../../Common/NET/PHY/SoftDemodulator/SyncAndPayloadDemodulator/: findSYNC.c findSYNC.h FreqDomMlseP4GfskStruct2.c FreqDomMlseP4GFSKStruct2.h processDerotatedSPDSamples.c processDerotatedSPDSamples.h SyncAndPayloadDemodulator.c SyncAndPayloadDemodulator.h SyncAndPayloadDemodulator_types.h
  group Source/Common/OS_AL_FreeRTOS
    ../../Common/FreeRTOS/10.4.3/OS_AL/: Event.c LinkedList.c MessageQ.c Mutex.c os_aclara.h os_que.h portable_aclara.h portable_freescale.h Queue.c Semaphore.c TickTime.c
  group Source/Common/Radio
    ../../Common/Radio/: radio.h
  group Source/Common/Radio/Si446x_Radio
    ../../Common/Radio/Si446x_Radio/: radio.c radio_config_normal.c radio_TCXO.c xradio.h
  group Source/Common/Radio/Si446x_Radio/Si446x_Library
    ../../Common/Radio/Si446x_Radio/Si446x_Library/: radio_comm.c
  group Source/Common/Radio/Si446x_Radio/Si446x_Library/Si446x
    ../../Common/Radio/Si446x_Radio/Si446x_Library/Si446x/: si446x_api_lib.c si446x_api_lib.h
  group Source/Common/Security
    ../../Common/Security/: cert-builder.c cert-builder.h ecc108_apps.c ecc108_apps.h ecc108_comm.c ecc108_comm.h ecc108_comm_marshaling.c ecc108_comm_marshaling.h ecc108_config.h ecc108_freertos.c ecc108_freertos.h ecc108_i2c.c ecc108_lib_return_codes.h ecc108_physical.h
  group Source/Common/Util
    ../../Common/: ascii.c ascii.h byteswap.c byteswap.h crc16.c crc16.h crc16_m.c crc16_m.h crc32.c crc32.h crc_custom.c crc_custom.h pack.c pack.h rand.c rand.h time_util.c time_util.h timer_util.c timer_util.h
  group Source/EP_Common
    ../Common/: APP_MSG_Handler.c App_Msg_Handler.h App_Msg_HandlerTable.h demand.c demand.h ed_config.c ed_config.h endpt_cim_cmd.c endpt_cim_cmd.h historyd.c historyd.h ID_intervalTask.c ID_intervalTask.h IDL_IdleProcess.c IDL_IdleProcess.h OR_MR_Handler.c OR_MR_Handler.h pwr_config.c pwr_config.h pwr_restore.c pwr_restore.h pwr_task.c pwr_task.h RG_CF_Handler.c RG_CF_Handler.h RG_MD_Handler.c RG_MD_Handler.h STRT_Startup.c STRT_Startup.h Task.c version.c version.h
  group Source/EP_Common/EP BuildConfig
    ../Common/BuildConfig/RA6_FreeRTOS/: cfg_app.h cfg_hal.h CompileSwitch.h filenames.h
  group Source/EP_Common/HMC
    ../Common/HMC/: hmc_app.c hmc_app.h hmc_demand.c hmc_demand.h hmc_diags.c hmc_diags.h hmc_ds.c hmc_ds.h hmc_eng.c hmc_eng.h hmc_finish.c hmc_finish.h hmc_msg.c hmc_msg.h hmc_mtr_info.c hmc_mtr_info.h hmc_prg_mtr.c hmc_prg_mtr.h hmc_prot.c hmc_prot.h hmc_request.c hmc_request.h hmc_seq_id.c HMC_seq_id.h hmc_snapshot.c hmc_snapshot.h hmc_start.c hmc_start.h hmc_sync.c hmc_sync.h hmc_time.c hmc_time.h hmc_tsk_lst.c hmc_tsk_lst.h intf_cim_cmd.c intf_cim_cmd.h
  group Source/EP_Common/Include
    ../Common/BuildConfig/RA6_FreeRTOS/: alarm_cfg.h dvr_banked_cfg.h dvr_intFlash_cfg.h partition_cfg.h user_settings.h
  group Source/EP_Common/LastGasp
    ../Common/: lpm_app.c lpm_app.h pwr_last_gasp.c pwr_last_gasp.h
  group Source/FSP_Gen
    ../OS_BSP/FreeRTOS_RA6/src/: hal_entry.c
    ../OS_BSP/FreeRTOS_RA6/ra_gen/: main.c
  group Source/TargetBuildConfig
    ../TargetBuildConfigs/I210+C/: features.h meter.h meter_ansi_sig.h
    ../TargetBuildConfigs/I210+C/RA6/: hal.h
