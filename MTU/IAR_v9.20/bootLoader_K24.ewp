# IAR project bootLoader_K24.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN1M0xxx12 NXP MK24FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050, Pe1665
  ICCARM.IExtraOptions: --error_limit=100; --no_path_in_file_macros
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\NXP; ..\Bootloader\Include; ..\Common\BuildConfig\K24_MQX; ..\TargetBuildConfigs\I210+C; ..\TargetBuildConfigs\I210+C\K24; ..\..\Common; ..\..\Common\driver; ..\..\Common\MQX\4.2.0\OS_AL; ..\Aclara_BSP; ..\Common; ..\..\Common; ..\..\Common\Security
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootLoader.bin
  ILINK.IlinkOutputFile: bootLoader.out
  ILINK.IlinkConfigDefines: TARGET=1
  ILINK.IlinkIcfFile: CommonScript_K24.icf
  ILINK.IlinkExtraOptions: --config_search ..\Bootloader\MK24F12
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Bootloader/: bootloader_main_BL.c
    ../../Common/: byteswap_BL.c byteswap_BL.h invert_bits_BL.c invert_bits_BL.h partitions_BL.c partitions_BL.h
    ../../Common/driver/: dvr_extflash_BL.c dvr_extflash_BL.h dvr_sharedMem_BL.c dvr_sharedMem_BL.h IF_intFlash_BL.c IF_intFlash_BL.h spi_mstr_BL.c spi_mstr_BL.h
    ../Aclara_BSP/: sys_clock_BL.c sys_clock_BL.h WDOG_BL.c
    ../Common/: version.c version.h
  group Include
    ../Aclara_BSP/: BSP_aclara_BL.h
    ../Common/BuildConfig/K24_MQX/: cfg_app_BL.h partition_cfg_BL.h
    ../Bootloader/Include/: features_BL.h
    ../../Common/: project_BL.h
  group MK24F12
    ../Bootloader/MK24F12/: boot_BL.S vectors_BL.c
