# IAR project I210+c_RA6_Dev_all.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA6E10F Renesas R7FA6E10F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCIncludePath2: ..\TargetBuildConfigs\I210+c; ..\TargetBuildConfigs\I210+c\RA6; ..\Aclara_BSP; ..\Common; ..\Common\HMC; ..\Common\BuildConfig\RA6_FreeRTOS; ..\OS_BSP\FreeRTOS_RA6\ra\arm\CMSIS_5\CMSIS\Core\Include; ..\OS_BSP\FreeRTOS_RA6\ra\fsp\inc; ..\OS_BSP\FreeRTOS_RA6\ra\fsp\inc\api; ..\OS_BSP\FreeRTOS_RA6\ra\fsp\inc\instances; ..\OS_BSP\FreeRTOS_RA6\ra\fsp\src\rm_freertos_port; ..\OS_BSP\FreeRTOS_RA6\ra_gen; ..\OS_BSP\FreeRTOS_RA6\src; ..\..\Common; ..\..\Common\Driver; ..\..\Common\DFW; ..\..\Common\Flash; ..\..\Common\FreeRTOS\10.4.3\OS_AL; ..\..\Common\FreeRTOS\10.4.3\aws\amazon-freertos\freertos_kernel\include; ..\..\Common\FreeRTOS\10.4.3\aws\amazon-freertos\libraries\freertos_plus\standard\freertos_plus_tcp\include; ..\..\Common\NET; ..\..\Common\NET\DTLS; ..\..\Common\NET\IP; ..\..\Common\NET\MAC; ..\..\Common\NET\MTLS; ..\..\Common\NET\PHY; ..\..\Common\NET\PHY\SoftDemodulator; ..\..\Common\NET\PHY\SoftDemodulator\SoftDemodPreProcessor; ..\..\Common\NET\PHY\SoftDemodulator\PreambleDetector; ..\..\Common\NET\PHY\SoftDemodulator\SyncAndPayloadDemodulator; ..\..\Common\Radio; ..\..\Common\Radio\Si446x_Radio; ..\..\Common\Radio\Si446x_Radio\Si446x_Library; ..\..\Common\Radio\Si446x_Radio\Si446x_Library\Si446x; ..\..\Common\Security; ..\..\Common\wolfssl; ..\OS_BSP\FreeRTOS_RA6\ra_cfg\fsp_cfg; ..\OS_BSP\FreeRTOS_RA6\ra_cfg; ..\OS_BSP\FreeRTOS_RA6\ra_cfg\aws; ..\OS_BSP\FreeRTOS_RA6\ra_cfg\driver; ..\OS_BSP\FreeRTOS_RA6\ra_cfg\fsp_cfg\bsp; ..\OS_BSP\FreeRTOS_RA6\ra\board
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Y84500-1-V3.00.xx.hex
  prebuild: AppPreBuild.bat "$OBJ_DIR$\Source\EP_Common"
  postbuild: AppPostBuild.bat "$TOOLKIT_DIR$" "$TARGET_BPATH$"
  ILINK.IlinkOutputFile: I210+c_RA6_Dev.out
  ILINK.IlinkConfigDefines: TARGET=2
  ILINK.IlinkIcfFile: script\fsp.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Flex Software/Build Configuration
    ../OS_BSP/FreeRTOS_RA6/ra_cfg/fsp_cfg/bsp/: board_cfg.h board_leds.c board_leds.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    ../OS_BSP/FreeRTOS_RA6/ra_cfg/aws/: FreeRTOSConfig.h
    ../OS_BSP/FreeRTOS_RA6/ra_cfg/fsp_cfg/: r_adc_cfg.h r_agt_cfg.h r_cgc_cfg.h r_crc_cfg.h r_dmac_cfg.h r_dtc_cfg.h r_elc_cfg.h r_flash_hp_cfg.h r_flash_lp_cfg.h r_gpt_cfg.h r_icu_cfg.h r_iic_master_cfg.h r_ioport_cfg.h r_lpm_cfg.h r_lvd_cfg.h r_poeg_cfg.h r_rtc_cfg.h r_sci_spi_cfg.h r_sci_uart_cfg.h r_spi_cfg.h r_wdt_cfg.h rm_comms_i2c_cfg.h
  group Flex Software/Components/BSP
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: base_addresses.h renesas.h system.h
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/inc/api/: bsp_api.h r_adc_api.h r_cgc_api.h r_crc_api.h r_elc_api.h r_external_irq_api.h r_flash_api.h r_i2c_master_api.h r_ioport_api.h r_lpm_api.h r_lvd_api.h r_poeg_api.h r_rtc_api.h r_spi_api.h r_spi_flash_api.h r_timer_api.h r_transfer_api.h r_uart_api.h r_wdt_api.h rm_comms_api.h
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/bsp/mcu/all/: bsp_arm_exceptions.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_rom_registers.c bsp_sbrk.c bsp_security.c bsp_security.h
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/bsp/mcu/ra6e1/: bsp_elc.h bsp_feature.h bsp_mcu_info.h
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/rm_freertos_port/: port.c portmacro.h
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_adc/: r_adc.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/inc/instances/: r_adc.h r_agt.h r_cgc.h r_crc.h r_dmac.h r_dtc.h r_elc.h r_flash_hp.h r_gpt.h r_icu.h r_iic_master.h r_ioport.h r_lpm.h r_lvd.h r_ospi.h r_poeg.h r_qspi.h r_rtc.h r_sci_spi.h r_sci_uart.h r_spi.h r_wdt.h rm_comms_i2c.h
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_agt/: r_agt.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_cgc/: r_cgc.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_crc/: r_crc.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_dmac/: r_dmac.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_dtc/: r_dtc.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_elc/: r_elc.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_flash_hp/: r_flash_hp.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_gpt/: r_gpt.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_icu/: r_icu.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_iic_master/: r_iic_master.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_ioport/: r_ioport.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_lpm/: r_lpm.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_lvd/: r_lvd.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_ospi/: r_ospi.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_poeg/: r_poeg.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_qspi/: r_qspi.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_rtc/: r_rtc.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_sci_spi/: r_sci_spi.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_sci_uart/: r_sci_uart.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_spi/: r_spi.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/r_wdt/: r_wdt.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/rm_comms_i2c/: rm_comms_i2c.c rm_comms_i2c_driver_ra.c
    ../OS_BSP/FreeRTOS_RA6/ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Components/CMSIS
    ../OS_BSP/FreeRTOS_RA6/ra/arm/CMSIS_5/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../OS_BSP/FreeRTOS_RA6/ra/arm/CMSIS_5/: LICENSE.txt
  group Flex Software/Components/FreeRTOS
    ../../Common/FreeRTOS/10.4.3/aws/amazon-freertos/freertos_kernel/include/: atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    ../../Common/FreeRTOS/10.4.3/aws/amazon-freertos/freertos_kernel/: event_groups.c LICENSE.md list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Common/FreeRTOS/10.4.3/aws/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c
    ../../Common/FreeRTOS/10.4.3/aws/amazon-freertos/: LICENSE
  group Flex Software/Generated Data
    ../OS_BSP/FreeRTOS_RA6/ra_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h pin_data.c vector_data.c vector_data.h
  group Source/Aclara_BSP
    ../Aclara_BSP/: ADC.c RTC.c
  group Source/Common
    ../../Common/: DBG_CommandLine.c DBG_CommandLine.h DBG_SerialDebug.c DBG_SerialDebug.h file_io.c file_io.h invert_bits.c invert_bits.h partitions.c partitions.h SELF_test.c SELF_test.h time_sys.c time_sys.h vbat_reg.c vbat_reg.h
  group Source/Common/Driver
    ../../Common/driver/: dvr_banked.c dvr_banked.h dvr_cache.c dvr_cache.h dvr_extflash.c dvr_extflash.h dvr_sectPreErase.c dvr_sectPreErase.h dvr_sharedMem.c dvr_sharedMem.h IF_intFlash.c IF_intFlash.h spi_mstr.c spi_mstr.h
  group Source/Common/OS_AL_FreeRTOS
    ../../Common/FreeRTOS/10.4.3/OS_AL/: Event.c MessageQ.c Mutex.c os_aclara.h os_que.h portable_aclara.h portable_freescale.h Queue.c Semaphore.c TickTime.c
  group Source/Common/Util
    ../../Common/: byteswap.c byteswap.h time_util.c time_util.h
  group Source/EP_Common
    ../Common/: pwr_last_gasp.c pwr_last_gasp.h STRT_Startup.c STRT_Startup.h Task.c version.c version.h
  group Source/EP_Common/EP BuildConfig
    ../Common/BuildConfig/RA6_FreeRTOS/: cfg_app.h cfg_hal.h
    ../Common/BuildConfig/K24_MQX/: CompileSwitch.h
  group Source/EP_Common/Include
    ../Common/BuildConfig/RA6_FreeRTOS/: alarm_cfg.h CompileSwitch.h dvr_banked_cfg.h dvr_intFlash_cfg.h filenames.h partition_cfg.h user_settings.h
  group Source/FSP_Gen
    ../OS_BSP/FreeRTOS_RA6/ra_gen/: blinky_thread.c blinky_thread.h main.c
    ../OS_BSP/FreeRTOS_RA6/src/: blinky_thread_entry.c hal_entry.c
    ../OS_BSP/FreeRTOS_RA6/ra/board/: board.h board_init.c board_init.h board_leds.h
  group Source/TargetBuildConfig
    ../TargetBuildConfigs/I210+C/: features.h meter.h meter_ansi_sig.h
    ../TargetBuildConfigs/I210+C/RA6/: hal.h
