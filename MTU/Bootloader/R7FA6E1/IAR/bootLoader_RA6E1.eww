<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\bootLoader_RA6E1.ewp</path>
    </project>
    <batchBuild/>
</workspace>
