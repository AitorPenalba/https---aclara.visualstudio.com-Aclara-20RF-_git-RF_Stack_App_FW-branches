# IAR project bootLoader_RA6E1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA6E10F Renesas R7FA6E10F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: _RENESAS_RA_
  ICCARM.CCIncludePath2: ../ra/arm/CMSIS_5/CMSIS/Core/Include; ../ra/fsp/inc; ../ra/fsp/inc/api; ../ra/fsp/inc/instances; ../ra_cfg/driver; ../ra_cfg/fsp_cfg; ../ra_cfg/fsp_cfg/bsp; ../ra_gen; ../src; ..\..\..\..\Common; ..\..\..\..\Common\driver; ..\..\..\..\Common\FreeRTOS\10.4.3\OS_AL; ..\..\Include; ..; ..\..\..\Common\BuildConfig\RA6_FreeRTOS; ..\..\..\Aclara_BSP
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: _RENESAS_RA_
  AARM.AUserIncludes: ../ra/arm/CMSIS_5/CMSIS/Core/Include; ../ra/fsp/inc; ../ra/fsp/inc/api; ../ra/fsp/inc/instances; ../ra_cfg/fsp_cfg; ../ra_cfg/fsp_cfg/bsp; ../ra_gen; ../src; ../ra_cfg/driver
  OBJCOPY.OOCOutputFile: bootLoader_RA6E1.bin
  ILINK.IlinkOutputFile: bootLoader_RA6E1.out
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RENESAS_RA_
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 0
  postbuild: cmd /c ""$RASC_EXE_PATH$" --gensecurebundle --compiler IAR "configuration.xml" "$TARGET_PATH$" 2> "%TEMP%\rasc_stderr.out""
  group Flex Software/Build Configuration
    ../ra_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    ../ra_cfg/fsp_cfg/: r_flash_hp_cfg.h r_ioport_cfg.h r_iwdt_cfg.h
    ../ra_cfg/driver/: r_qspi_cfg.h
  group Flex Software/Components
    ../ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: base_addresses.h renesas.h system.h
    ../ra/fsp/inc/api/: bsp_api.h r_cgc_api.h r_flash_api.h r_ioport_api.h r_spi_flash_api.h r_wdt_api.h
    ../ra/fsp/src/bsp/mcu/all/: bsp_arm_exceptions.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_rom_registers.c bsp_sbrk.c bsp_security.c bsp_security.h bsp_tfu.h
    ../ra/fsp/src/bsp/mcu/ra6e1/: bsp_elc.h bsp_feature.h bsp_mcu_info.h
    ../ra/arm/CMSIS_5/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../ra/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    ../ra/arm/CMSIS_5/: LICENSE.txt
    ../ra/fsp/src/r_flash_hp/: r_flash_hp.c
    ../ra/fsp/inc/instances/: r_flash_hp.h r_ioport.h r_iwdt.h r_qspi.h
    ../ra/fsp/src/r_ioport/: r_ioport.c
    ../ra/fsp/src/r_iwdt/: r_iwdt.c
    ../ra/fsp/src/r_qspi/: r_qspi.c
    ../ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    ../ra_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    ../src/: hal_entry.c
  group Include
    ../../Include/: features.h
  group R7FA6E1
    ../: hal.h
  group Source
    ../../: bootloader_main_BL.c
    ../../../Aclara_BSP/: BSP_aclara_BL.h sys_clock_BL.c sys_clock_BL.h WDOG_BL.c
    ../../../../Common/: byteswap_BL.c byteswap_BL.h crc32.c crc32.h invert_bits_BL.c invert_bits_BL.h partitions_BL.c partitions_BL.h project_BL.h
    ../../../../Common/driver/: dvr_extflash_BL.c dvr_extflash_BL.h dvr_sharedMem_BL.c dvr_sharedMem_BL.h IF_intFlash_BL.c IF_intFlash_BL.h
    ../../../Common/BuildConfig/RA6_FreeRTOS/: partition_cfg_BL.h
    ../../../Common/: version.c version.h
