# IAR project I210+c_RA6_Dev.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA6E10F Renesas R7FA6E10F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCIncludePath2: ..\TargetBuildConfigs\I210+c; ..\TargetBuildConfigs\I210+c\RA6; ..\TargetBuildConfigs\I210+c\RA6\ra_cfg\aws; ..\TargetBuildConfigs\I210+c\RA6\ra_cfg\driver; ..\TargetBuildConfigs\I210+c\RA6\ra_cfg\fsp_cfg; ..\TargetBuildConfigs\I210+c\RA6\ra_cfg\fsp_cfg\bsp; ..\Aclara_BSP; ..\Common; ..\Common\HMC; ..\Common\BuildConfig\RA6_FreeRTOS; ..\OS_BSP\FreeRTOS_RA6\ra\arm\CMSIS_5\CMSIS\Core\Include; ..\OS_BSP\FreeRTOS_RA6\ra\fsp\inc; ..\OS_BSP\FreeRTOS_RA6\ra\fsp\inc\api; ..\OS_BSP\FreeRTOS_RA6\ra\fsp\inc\instances; ..\OS_BSP\FreeRTOS_RA6\ra\fsp\src\rm_freertos_port; ..\OS_BSP\FreeRTOS_RA6\ra_gen; ..\OS_BSP\FreeRTOS_RA6\src; ..\..\Common; ..\..\Common\Driver; ..\..\Common\DFW; ..\..\Common\Flash; ..\..\Common\FreeRTOS\10.4.3\OS_AL; ..\..\Common\FreeRTOS\10.4.3\aws\amazon-freertos\freertos_kernel\include; ..\..\Common\FreeRTOS\10.4.3\aws\amazon-freertos\libraries\freertos_plus\standard\freertos_plus_tcp\include; ..\..\Common\NET; ..\..\Common\NET\DTLS; ..\..\Common\NET\IP; ..\..\Common\NET\MAC; ..\..\Common\NET\MTLS; ..\..\Common\NET\PHY; ..\..\Common\NET\PHY\SoftDemodulator; ..\..\Common\NET\PHY\SoftDemodulator\SoftDemodPreProcessor; ..\..\Common\NET\PHY\SoftDemodulator\PreambleDetector; ..\..\Common\NET\PHY\SoftDemodulator\SyncAndPayloadDemodulator; ..\..\Common\Radio; ..\..\Common\Radio\Si446x_Radio; ..\..\Common\Radio\Si446x_Radio\Si446x_Library; ..\..\Common\Radio\Si446x_Radio\Si446x_Library\Si446x; ..\..\Common\Security; ..\..\Common\wolfssl
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Y84500-1-V3.00.xx.hex
  prebuild: AppPreBuild.bat "$OBJ_DIR$\Source\EP_Common"
  postbuild: AppPostBuild.bat "$TOOLKIT_DIR$" "$TARGET_BPATH$"
  ILINK.IlinkOutputFile: I210+c_RA6_Dev.out
  ILINK.IlinkConfigDefines: TARGET=2
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Libraries/RA6_FreeRTOS/Debug
    ../OS_BSP/FreeRTOS_RA6/IAR/Debug/Exe/: FreeRTOS_RA6.a
  group Source
    ../OS_BSP/FreeRTOS_RA6/src/: hal_entry.c
    ../OS_BSP/FreeRTOS_RA6/ra_gen/: main.c
