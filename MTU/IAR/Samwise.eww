<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bootLoader_K24.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\OS_BSP\MQX_Kinetis\mqx\build\iar\bsp_ep_k24f120m\bsp_ep_k24f120m.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\EdgeGateway_K24.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\OS_BSP\FreeRTOS_RA6\IAR\EP_FreeRTOS_RA6.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\I210+c_K24.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\I210+c_RA6.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\I210+c_RA6_Dev.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\KV2c_K24.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LoadControl_K24.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\OS_BSP\MQX_Kinetis\mqx\build\iar\psp_ep_k24f120m\psp_ep_k24f120m.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\Common\wolfssl\IDE\IAR-EWARM\Projects\MTU\wolfSSL-Lib_K24_MQX.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\Common\wolfssl\IDE\IAR-EWARM\Projects\MTU\wolfSSL-Lib_RA6_FreeRTOS.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>GE_KV2c_Debug</name>
            <member>
                <project>bsp_ep_k24f120m</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>psp_ep_k24f120m</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_MTU</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>bootLoader</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>GE_KV2c</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>GE_KV2c_Release</name>
            <member>
                <project>bsp_twrk24f120m</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>psp_twrk24f120m</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>GE_KV2c</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Libs - Debug</name>
            <member>
                <project>bsp_ep_k24f120m</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>psp_ep_k24f120m</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_MTU</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Libs - Release</name>
            <member>
                <project>bsp_ep_k24f120m</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>psp_ep_k24f120m</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_MTU</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Debug</name>
            <member>
                <project>bsp_ep_k24f120m</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>psp_ep_k24f120m</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_MTU</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>bootLoader</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>Aclara_DA</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>Aclara_LC</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>GE_I210+c</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>GE_KV2c</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>GE_i210+c_Debug</name>
            <member>
                <project>bsp_ep_k24f120m</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>psp_ep_k24f120m</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_MTU</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>bootLoader</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>GE_I210+c</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Bootloader- Debug</name>
        </batchDefinition>
        <batchDefinition>
            <name>Aclara_LC - Debug</name>
            <member>
                <project>bsp_ep_k24f120m</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>psp_ep_k24f120m</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_MTU</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>bootLoader</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>Aclara_LC</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Aclara_DA</name>
            <member>
                <project>bsp_ep_k24f120m</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>psp_ep_k24f120m</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>wolfSSL-Lib_MTU</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>bootLoader</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>Aclara_DA</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
