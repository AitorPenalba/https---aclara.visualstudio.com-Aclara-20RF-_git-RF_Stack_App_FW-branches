# IAR project bootLoader_K24.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN1M0xxx12 NXP MK24FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050, Pe1665
  ICCARM.IExtraOptions: --error_limit=100; --no_path_in_file_macros
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\NXP; ..\BootLoader\BuildConfig; ..\Common\BuildConfig\K24_MQX; ..\TargetBuildConfigs\I210+C; ..\TargetBuildConfigs\I210+C\K24; ..\..\Common; ..\..\Common\driver; ..\..\Common\MQX\4.2.0\OS_AL; ..\Aclara_BSP; ..\Common; ..\..\Common; ..\..\Common\Security
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootLoader.bin
  ILINK.IlinkOutputFile: bootLoader.out
  ILINK.IlinkConfigDefines: TARGET=1
  ILINK.IlinkIcfFile: CommonScript_K24.icf
  ILINK.IlinkExtraOptions: --config_search ..\Bootloader\BuildConfig
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../BootLoader/: boot.S bootloader_main.c vectors.c
    ../../Common/: byteswap.c byteswap.h invert_bits.c invert_bits.h partitions.c
    ../../Common/driver/: dvr_extflash.c dvr_extflash.h dvr_sharedMem.c dvr_sharedMem.h IF_intFlash.c IF_intFlash.h spi_mstr.c spi_mstr.h
    ../Aclara_BSP/: sys_clock.c sys_clock.h WDOG.c
    ../Common/: version.c version.h
  group BuildConfig
    ../Aclara_BSP/: BSP_aclara.h
    ../Common/BuildConfig/K24_MQX/: cfg_app.h partition_cfg.h
    ../BootLoader/Include/: meter.h
    ../../Common/: project.h
