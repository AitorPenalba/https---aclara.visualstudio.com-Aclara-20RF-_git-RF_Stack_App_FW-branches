# IAR project bsp_ep_k24f120m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN1M0xxx12 NXP MK24FN1M0xxx12
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EP=1; HAL_TARGET_HARDWARE=HAL_TARGET_Y84020_1_REVA; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa050,Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../../../source/io/adc/kadc; ../../../source/io/adc; ../../../source/io/cm; ../../../source/io/crc; ../../../../config/ep_k24f120m; ../../../source/io/dma; ../../../source/io/flashx/freescale; ../../../source/io/flashx; ../../../source/io/gpio/kgpio; ../../../source/io/gpio; ../../../source/io/hwtimer; ../../../source/io/i2c; ../../../source/io/i2c/polled; ../../../source/io/i2c/int; ../../../source/bsp/ep_k24f120m; ../../../../config/common; ../../../source/include; ../../../source/io/enet; ../../../source/io/debug; ../../../source/io/io_mem; ../../../source/io/io_null; ../../../source/io/pipe; ../../../source/io/lpm; ../../../source/io/lwadc; ../../../source/io/lwgpio; ../../../source/io/pcb; ../../../source/io/pcb/mqxa; ../../../source/io/pccard; ../../../source/io/pcflash; ../../../source/io/rnga; ../../../source/io/rtc; ../../../source/io/sai; ../../../source/io/sai/int; ../../../source/io/sdcard/sdcard_spi; ../../../source/io/sdcard; ../../../source/io/serial; ../../../source/io/spi; ../../../source/io/tfs; ../../../source/io/timer; ../../../source/io/usb; ../../../source/io/usb_dcd; ../../../source/io/usb_dcd/polled; ../../../source/io/usb_dcd/int; ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m/cpu; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/core/M4; ../../../source/tad; ../../../../../../MTU; ../../../../../../MTU/Common; ../../../../../../MTU/Common/BuildConfig\K24_MQX
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../source/io/adc/kadc; ../../../source/io/adc; ../../../source/io/cm; ../../../../config/ep_k24f120m; ../../../source/io/dma; ../../../source/io/flashx/freescale; ../../../source/io/flashx; ../../../source/io/gpio/kgpio; ../../../source/io/gpio; ../../../source/io/hwtimer; ../../../source/io/i2c; ../../../source/io/i2c/polled; ../../../source/io/i2c/int; ../../../source/bsp/ep_k24f120m; ../../../../config/common; ../../../source/include; ../../../source/io/enet; ../../../source/io/debug; ../../../source/io/io_mem; ../../../source/io/io_null; ../../../source/io/pipe; ../../../source/io/lpm; ../../../source/io/lwadc; ../../../source/io/lwgpio; ../../../source/io/pcb; ../../../source/io/pcb/mqxa; ../../../source/io/pccard; ../../../source/io/pcflash; ../../../source/io/rnga; ../../../source/io/rtc; ../../../source/io/sai; ../../../source/io/sai/int; ../../../source/io/sdcard/sdcard_spi; ../../../source/io/sdcard; ../../../source/io/serial; ../../../source/io/spi; ../../../source/io/tfs; ../../../source/io/timer; ../../../source/io/usb; ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m/cpu; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/core/M4; ../../../source/tad
  postbuild: "../../bat/bsp_ep_k24f120m.bat" "../../../.." "../../../../lib/ep_k24f120m.iar/debug/bsp"
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK24FN1M0xxx12 Freescale MK24FN1M0xxx12
  ICCARM.CCIncludePath2: ../../../source/io/adc/kadc; ../../../source/io/adc; ../../../source/io/cm; ../../../../config/ep_k24f120m; ../../../source/io/dma; ../../../source/io/flashx/freescale; ../../../source/io/flashx; ../../../source/io/gpio/kgpio; ../../../source/io/gpio; ../../../source/io/hwtimer; ../../../source/io/i2c; ../../../source/io/i2c/polled; ../../../source/io/i2c/int; ../../../source/bsp/ep_k24f120m; ../../../../config/common; ../../../source/include; ../../../source/io/enet; ../../../source/io/debug; ../../../source/io/io_mem; ../../../source/io/io_null; ../../../source/io/pipe; ../../../source/io/lpm; ../../../source/io/lwadc; ../../../source/io/lwgpio; ../../../source/io/pcb; ../../../source/io/pcb/mqxa; ../../../source/io/pccard; ../../../source/io/pcflash; ../../../source/io/rnga; ../../../source/io/rtc; ../../../source/io/sai; ../../../source/io/sai/int; ../../../source/io/sdcard/sdcard_spi; ../../../source/io/sdcard; ../../../source/io/serial; ../../../source/io/spi; ../../../source/io/tfs; ../../../source/io/timer; ../../../source/io/usb; ../../../source/io/usb_dcd; ../../../source/io/usb_dcd/polled; ../../../source/io/usb_dcd/int; ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m/cpu; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/core/M4; ../../../source/tad
  postbuild: ../../../../mqx/build/bat/bsp_ep_k24f120m.bat ../../../.. ../../../../lib/ep_k24f120m.iar/release/bsp iar
  ILINK.IlinkOutputFile: libgeneric.out
  group BSP Files
    ../../../source/bsp/ep_k24f120m/: bsp.h bsp_cm.c bsp_cm.h bsp_prv.h bsp_rev.h ep_k24f120m.h init_adc.c init_bsp.c init_dma.c init_flashx.c init_gpio.c init_hw.c init_i2c.c init_lpm.c init_lpm.h init_lwadc.c init_sci.c init_spi.c mqx_init.c mqx_main.c PE_LDD.h PE_Types.h vectors.c
    ../../../source/io/enet/: ethernet.h
    ../../../../config/common/: maximum_config.h small_ram_config.h smallest_config.h verif_enabled_config.h
    ../../../source/include/: mqx.h
  group default
    ../../../source/io/rnga/: krnga.c rnga.h
  group Generic IO Drivers/cm
    ../../../source/io/cm/: cm.c cm.h cm_kinetis.h
  group Generic IO Drivers/debug
    ../../../source/io/debug/: iodebug.c iodebug.h iodebug_asm.S iodebug_prv.h
  group Generic IO Drivers/io_mem
    ../../../source/io/io_mem/: io_mem.c io_mem.h iomemprv.h
  group Generic IO Drivers/io_null
    ../../../source/io/io_null/: io_null.c io_null.h ionulprv.h
  group Generic IO Drivers/iopipe
    ../../../source/io/pipe/: io_pipe.c io_pipe.h pipe_prv.h
  group Generic IO Drivers/lpm
    ../../../source/io/lpm/: lpm.c lpm.h lpm_kinetis.h lpm_prv.h lpm_smc.c
  group Peripheral IO Drivers/adc
    ../../../source/io/adc/: adc.c adc.h adc_conf.h adc_prv.h
    ../../../source/io/adc/kadc/: adc_mk24.c adc_mk24.h
  group Peripheral IO Drivers/adc/kadc
    ../../../source/io/adc/kadc/: adc_kadc.c adc_kadc.h adc_kadc_prv.h adt_kpdb.c
  group Peripheral IO Drivers/crc
    ../../../source/io/crc/: crc_kn.c crc_kn.h
  group Peripheral IO Drivers/dma
    ../../../source/io/dma/: dma.c dma.h edma.c edma.h edma_kinetis.c edma_prv.h
  group Peripheral IO Drivers/flashx
    ../../../source/io/flashx/freescale/: flash_mk24.c flash_mk24.h
    ../../../source/io/flashx/: flashx.c flashx.h flashxprv.h
  group Peripheral IO Drivers/flashx/freescale
    ../../../source/io/flashx/freescale/: flash_ftfe.c flash_ftfe.h flash_ftfe_prv.h
  group Peripheral IO Drivers/gpio
    ../../../source/io/gpio/: io_gpio.c io_gpio.h io_gpio_prv.h
  group Peripheral IO Drivers/gpio/knxx
    ../../../source/io/gpio/kgpio/: io_gpio_kgpio.c io_gpio_kgpio.h io_gpio_kgpio_prv.h
  group Peripheral IO Drivers/hwtimer
    ../../../source/io/hwtimer/: hwtimer.c hwtimer.h hwtimer_kinetis.c hwtimer_lpt.c hwtimer_lpt.h hwtimer_pit.c hwtimer_pit.h hwtimer_systick.c hwtimer_systick.h
  group Peripheral IO Drivers/i2c
    ../../../source/io/i2c/: i2c.h i2c_ki2c.h i2c_ki2c_prv.h i2c_mk24.c
    ../../../source/io/i2c/int/: i2c_int_ki2c.c
    ../../../source/io/i2c/polled/: i2c_pol_ki2c.c
  group Peripheral IO Drivers/i2c/int
    ../../../source/io/i2c/int/: i2c_int.c i2c_int_prv.h
  group Peripheral IO Drivers/i2c/polled
    ../../../source/io/i2c/polled/: i2c_pol.c i2c_pol_prv.h
  group Peripheral IO Drivers/lwadc
    ../../../source/io/lwadc/: lwadc.h lwadc_k24.c
  group Peripheral IO Drivers/lwadc/kadc
    ../../../source/io/lwadc/: lwadc_kadc.c lwadc_kadc.h lwadc_kadc_prv.h
  group Peripheral IO Drivers/lwgpio
    ../../../source/io/lwgpio/: lwgpio.c lwgpio.h
  group Peripheral IO Drivers/lwgpio/kgpio
    ../../../source/io/lwgpio/: lwgpio_kgpio.c lwgpio_kgpio.h
  group Peripheral IO Drivers/rtc
    ../../../source/io/rtc/: krtc.c krtc.h rtc.h
  group Peripheral IO Drivers/serial
    ../../../source/io/serial/: io_sinit.c serial.h serinprv.h serl_kuart.h serl_mk24.c serplprv.h
  group Peripheral IO Drivers/serial/dma
    ../../../source/io/serial/dma/: serl_dma_kuart.c
  group Peripheral IO Drivers/serial/int
    ../../../source/io/serial/int/: serl_int.c serl_int_kuart.c
  group Peripheral IO Drivers/serial/polled
    ../../../source/io/serial/polled/: serl_pol.c serl_pol_kuart.c
  group Peripheral IO Drivers/timer
    ../../../source/io/timer/: qpit.h timer_kinetis.c timer_qpit.c timer_qpit.h
  group User Config
    ../../../../config/ep_k24f120m/: user_config.h
