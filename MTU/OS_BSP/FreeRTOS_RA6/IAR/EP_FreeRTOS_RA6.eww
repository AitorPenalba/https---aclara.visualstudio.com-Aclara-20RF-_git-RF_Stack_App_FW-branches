<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\EP_FreeRTOS_RA6.ewp</path>
    </project>
    <batchBuild/>
</workspace>
