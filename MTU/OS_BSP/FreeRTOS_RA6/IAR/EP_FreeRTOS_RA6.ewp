# IAR project EP_FreeRTOS_RA6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA6E10F Renesas R7FA6E10F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: _RENESAS_RA_
  ICCARM.CCIncludePath2: ..\..\..\..\Common\FreeRTOS\10.4.3\aws\amazon-freertos\freertos_kernel\include; ..\..\..\..\Common\FreeRTOS\10.4.3\aws\amazon-freertos\libraries\freertos_plus\standard\freertos_plus_tcp\include; ..\ra\arm\CMSIS_5\CMSIS\Core\Include; ..\ra\fsp\inc; ..\ra\fsp\inc\api; ..\ra\fsp\inc\instances; ..\ra\fsp\src\rm_freertos_port; ..\ra_gen; ..\src; ..\ra_cfg\aws; ..\ra_cfg\driver; ..\ra\board; ..\ra_cfg\fsp_cfg; ..\ra_cfg\fsp_cfg\bsp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _RENESAS_RA_
  AARM.AUserIncludes: ..\ra\arm\CMSIS_5\CMSIS\Core\Include; ..\..\..\..\Common\FreeRTOS\10.4.3\aws\amazon-freertos\freertos_kernel\include; ..\..\..\..\Common\FreeRTOS\10.4.3\aws\amazon-freertos\libraries\freertos_plus\standard\freertos_plus_tcp\include; ..\ra\fsp\inc; ..\ra\fsp\inc\api; ..\ra\fsp\inc\instances; ..\ra\fsp\src\rm_freertos_port; ..\ra_gen; ..\src; ..\..\..\TargetBuildConfigs\I210+C\RA6\ra_cfg\aws; ..\..\..\TargetBuildConfigs\I210+C\RA6\ra_cfg\driver; ..\..\..\TargetBuildConfigs\I210+C\RA6\ra_cfg\fsp_cfg; ..\..\..\TargetBuildConfigs\I210+C\RA6\ra_cfg\fsp_cfg\bsp
  ILINK.IlinkOutputFile: MultiBspAndTasks.out
  ILINK.IlinkIcfFile: script\fsp.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Flex Software/Build Configuration
    ../ra_cfg/fsp_cfg/bsp/: board_cfg.h board_leds.c board_leds.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    ../ra_cfg/aws/: FreeRTOSConfig.h
    ../ra_cfg/fsp_cfg/: r_adc_cfg.h r_agt_cfg.h r_cgc_cfg.h r_crc_cfg.h r_dmac_cfg.h r_flash_hp_cfg.h r_flash_lp_cfg.h r_gpt_cfg.h r_icu_cfg.h r_iic_master_cfg.h r_ioport_cfg.h r_lpm_cfg.h r_lvd_cfg.h r_poeg_cfg.h r_rtc_cfg.h r_sci_spi_cfg.h r_sci_uart_cfg.h r_wdt_cfg.h rm_comms_i2c_cfg.h
  group Flex Software/Components/BSP
    ../ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: base_addresses.h renesas.h system.h
    ../ra/fsp/inc/api/: bsp_api.h r_adc_api.h r_cgc_api.h r_crc_api.h r_elc_api.h r_external_irq_api.h r_flash_api.h r_i2c_master_api.h r_ioport_api.h r_lpm_api.h r_lvd_api.h r_poeg_api.h r_rtc_api.h r_spi_api.h r_spi_flash_api.h r_timer_api.h r_transfer_api.h r_uart_api.h r_wdt_api.h rm_comms_api.h
    ../ra/fsp/src/bsp/mcu/all/: bsp_arm_exceptions.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_rom_registers.c bsp_sbrk.c bsp_security.c bsp_security.h
    ../ra/fsp/src/bsp/mcu/ra6e1/: bsp_elc.h bsp_feature.h bsp_mcu_info.h
    ../ra/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    ../ra/fsp/src/rm_freertos_port/: port.c portmacro.h
    ../ra/fsp/src/r_adc/: r_adc.c
    ../ra/fsp/inc/instances/: r_adc.h r_agt.h r_cgc.h r_crc.h r_dmac.h r_flash_hp.h r_gpt.h r_icu.h r_iic_master.h r_ioport.h r_lpm.h r_lvd.h r_ospi.h r_poeg.h r_qspi.h r_rtc.h r_sci_spi.h r_sci_uart.h r_wdt.h rm_comms_i2c.h
    ../ra/fsp/src/r_agt/: r_agt.c
    ../ra/fsp/src/r_cgc/: r_cgc.c
    ../ra/fsp/src/r_crc/: r_crc.c
    ../ra/fsp/src/r_dmac/: r_dmac.c
    ../ra/fsp/src/r_flash_hp/: r_flash_hp.c
    ../ra/fsp/src/r_gpt/: r_gpt.c
    ../ra/fsp/src/r_icu/: r_icu.c
    ../ra/fsp/src/r_iic_master/: r_iic_master.c
    ../ra/fsp/src/r_ioport/: r_ioport.c
    ../ra/fsp/src/r_lpm/: r_lpm.c
    ../ra/fsp/src/r_lvd/: r_lvd.c
    ../ra/fsp/src/r_ospi/: r_ospi.c
    ../ra/fsp/src/r_poeg/: r_poeg.c
    ../ra/fsp/src/r_qspi/: r_qspi.c
    ../ra/fsp/src/r_rtc/: r_rtc.c
    ../ra/fsp/src/r_sci_spi/: r_sci_spi.c
    ../ra/fsp/src/r_sci_uart/: r_sci_uart.c
    ../ra/fsp/src/r_wdt/: r_wdt.c
    ../ra/fsp/src/rm_comms_i2c/: rm_comms_i2c.c rm_comms_i2c_driver_ra.c
    ../ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Components/CMSIS
    ../ra/arm/CMSIS_5/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../ra/arm/CMSIS_5/: LICENSE.txt
  group Flex Software/Components/FreeRTOS
    ../../../../Common/FreeRTOS/10.4.3/aws/amazon-freertos/freertos_kernel/include/: atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    ../../../../Common/FreeRTOS/10.4.3/aws/amazon-freertos/freertos_kernel/: event_groups.c LICENSE.md list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Common/FreeRTOS/10.4.3/aws/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c
    ../../../../Common/FreeRTOS/10.4.3/aws/amazon-freertos/: LICENSE
  group Flex Software/Generated Data
    ../ra_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h pin_data.c vector_data.c vector_data.h
